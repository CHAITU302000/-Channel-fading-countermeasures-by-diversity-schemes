options:
  parameters:
    generate_options: qt_gui
    id: Rxmimo
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    precision: '16'
    type: qpsk
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j]'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: variable_constellation_0
    step_size: '.0001'
    type: lms
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 675e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 725e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: sps
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '10000'
    type: '0'
  states: {}
- name: digital_probe_mpsk_snr_est_c_0_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '10000'
    type: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      from gnuradio import grc
      import inspect


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='condition_block',   # will show up in GRC
                  in_sig=[np.complex64,np.complex64],
                  out_sig=[np.complex64]
              )
              self.selectPortName = 'snr1'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_msg_first)
              self.selectPort = 'snr2'
              self.message_port_register_in(pmt.intern(self.selectPort))
              self.set_msg_handler(pmt.intern(self.selectPort), self.handle_msg_second)
              self.first_snr = 0
              self.second_snr = 0
              "self.thershold=4"
              self.is_mod_changed=False;
              self.selector=0
              self.last_selector=0
              self.tag_added=True
              self.index=0;
          
          def handle_msg_first(self,msg_snr1):
              self.first_snr=pmt.to_double(msg_snr1)
          
          def handle_msg_second(self,msg_snr2):
              self.second_snr=pmt.to_double(msg_snr2)
          
          
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if self.first_snr > 4 and self.second_snr< 4:
                 self.selector=0
              elif self.first_snr < 4 and self.second_snr > 4:
                     self.selector=1
              elif self.first_snr < 4 and self.second_snr < 4 and self.first_snr > self.second_snr:
                      self.selector=0
              elif self.first_snr < 4 and self.second_snr < 4 and self.first_snr < self.second_snr:
                      self.selector=1
              elif self.first_snr > 4 and self.second_snr > 4 and self.first_snr > self.second_snr:
                      self.selector=0
              elif self.first_snr > 4 and self.second_snr >4 and self.first_snr < self.second_snr:
                     self.selector=1

              else:
                   self.selector=1  
             
              output_items[0][:] = input_items[self.selector]
              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      from gnuradio import grc
      import inspect


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='condition_block',   # will show up in GRC
                  in_sig=[np.complex64,np.complex64],
                  out_sig=[np.complex64]
              )
              self.selectPortName = 'snr1'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_msg_first)
              self.selectPort = 'snr2'
              self.message_port_register_in(pmt.intern(self.selectPort))
              self.set_msg_handler(pmt.intern(self.selectPort), self.handle_msg_second)
              self.first_snr = 0
              self.second_snr = 0
              "self.thershold=4"
              self.is_mod_changed=False;
              self.selector=0
              self.last_selector=0
              self.tag_added=True
              self.index=0;
          
          def handle_msg_first(self,msg_snr1):
              self.first_snr=pmt.to_double(msg_snr1)
          
          def handle_msg_second(self,msg_snr2):
              self.second_snr=pmt.to_double(msg_snr2)
          
          
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if self.first_snr > 4 and self.second_snr< 4:
                 self.selector=0
              elif self.first_snr < 4 and self.second_snr > 4:
                     self.selector=1
              elif self.first_snr < 4 and self.second_snr < 4 and self.first_snr > self.second_snr:
                      self.selector=0
              elif self.first_snr < 4 and self.second_snr < 4 and self.first_snr < self.second_snr:
                      self.selector=1
              elif self.first_snr > 4 and self.second_snr > 4 and self.first_snr > self.second_snr:
                      self.selector=0
              elif self.first_snr > 4 and self.second_snr >4 and self.first_snr < self.second_snr:
                     self.selector=1

              else:
                   self.selector=1  
             
              output_items[0][:] = input_items[self.selector]
              return len(output_items[0])
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: '"hackrf2"'
    args: '"rtl"'
    bb_gain0: '20'
    bw0: 100e6
    freq0: 700e6
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 100e6
    fc: 700e6
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 100e6
    fc: 700e6
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_sub_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_sub_xx_1, '1']
- [blocks_sub_xx_0, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [blocks_sub_xx_0, '0', epy_block_0, '0']
- [blocks_sub_xx_0, '0', epy_block_0_0, '0']
- [blocks_sub_xx_1, '0', digital_probe_mpsk_snr_est_c_0_0, '0']
- [blocks_sub_xx_1, '0', epy_block_0, '1']
- [blocks_sub_xx_1, '0', epy_block_0_0, '1']
- [digital_linear_equalizer_0, '0', blocks_sub_xx_0, '1']
- [digital_linear_equalizer_0, '0', blocks_sub_xx_1, '0']
- [digital_probe_mpsk_snr_est_c_0, snr, epy_block_0, snr1]
- [digital_probe_mpsk_snr_est_c_0, snr, epy_block_0_0, snr2]
- [digital_probe_mpsk_snr_est_c_0_0, snr, epy_block_0, snr2]
- [digital_probe_mpsk_snr_est_c_0_0, snr, epy_block_0_0, snr1]
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', digital_linear_equalizer_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
